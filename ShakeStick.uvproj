# Keil uVision project ShakeStick.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89S52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(33000000) MODP2
  output: ShakeStick +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: C:\DevTool\Keil_v5\C51\INC\**;.\src\APP;.\src\BSP;.\src\EXT-LIB
  link misc: REMOVEUNUSED
  group APP
    ./src/APP/: main.c cfg.h STARTUP.A51
  group BSP
    ./src/BSP/: bsp.c bsp.h bsp_kbd.c bsp_kbd.h bsp_led.c bsp_led.h
  group EXT-LIB
    ./src/EXT-LIB/: lib_delay.c lib_delay.h lib_stdint.h lib_math.c lib_math.h lib_util.c lib_util.h
